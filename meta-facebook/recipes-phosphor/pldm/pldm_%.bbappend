PACKAGECONFIG:append = " oem-meta"
PACKAGECONFIG:remove = "softoff"
