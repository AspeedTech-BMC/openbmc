FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append = " file://0001-ast2700-dcscm-add-dbus-for-x86-power-control.patch"
