# Override i3c-attestation-emu.service: AST2700 brings up the PFR MCTP I3C
# link (mctpi3c4/mctpi3ct4) on net 1.
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
