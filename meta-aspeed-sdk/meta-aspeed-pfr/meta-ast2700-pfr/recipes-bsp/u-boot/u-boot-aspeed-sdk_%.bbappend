FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

require u-boot-common-ast2700-dcscm.inc
