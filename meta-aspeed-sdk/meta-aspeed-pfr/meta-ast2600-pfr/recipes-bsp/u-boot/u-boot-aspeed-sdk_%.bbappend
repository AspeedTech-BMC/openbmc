FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:ast2600-dcscm = " \
	file://intel-avenue-city-crb.cfg \
"

