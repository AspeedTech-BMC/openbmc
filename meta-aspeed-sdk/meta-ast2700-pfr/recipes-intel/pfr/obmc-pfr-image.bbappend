FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
PFR_MANIFEST ?= "pfr_manifest_ast2700_dcscm.json"
