require aspeed-coprocessor.inc
