ASPEED_ZEPHYR_PROJECT_BRANCH:ast2700-irot = "aspeed-dev"
EXTRA_OECMAKE:append:ast2700-irot = " -DEXTRA_DTC_OVERLAY_FILE=boards/irot.overlay "

