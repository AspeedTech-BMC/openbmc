EXTRA_OECMAKE:append:ast-irot = " -DEXTRA_DTC_OVERLAY_FILE=boards/irot.overlay "
