CALIPTRA_AUTH_MANIFEST_APP = "caliptra-auth-manifest-app-1x"

require cptra-imgtool.inc
