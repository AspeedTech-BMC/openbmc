CALIPTRA_AUTH_MANIFEST_APP = "caliptra-auth-manifest-app-2x"

require cptra-imgtool.inc
