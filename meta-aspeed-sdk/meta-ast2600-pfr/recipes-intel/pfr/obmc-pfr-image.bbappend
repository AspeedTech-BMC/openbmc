FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

PFR_MANIFEST ?= "pfr_manifest_ast2600_dcscm.json"
