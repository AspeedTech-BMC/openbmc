# Set the overlay config for mcu-runtime bundle build.
EXTRA_OECMAKE += "-DOVERLAY_CONFIG=boards/ast2700_evb_ast2700_a1_bootmcu_force_man_bundle_offset.conf"
