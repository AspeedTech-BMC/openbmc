RDEPENDS:${PN}-inband:remove = " \
    phosphor-ipmi-bt \
    "
