# The AST2700 DCSCM rofs does not have enough space.
# Remove the following tool to free up space in the rofs.
RRECOMMENDS:${PN}-ktools:remove = " \
    perf \
    "
