
IMAGE_INSTALL_append = "phosphor-webui virtual-obmc-host-ipmi-kcs phosphor-ipmi-host"
