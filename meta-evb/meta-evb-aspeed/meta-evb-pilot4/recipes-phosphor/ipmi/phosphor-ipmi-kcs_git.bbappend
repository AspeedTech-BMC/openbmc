KCS_DEVICE = "ipmi-kcs1"
PROVIDES = "virtual/obmc-host-ipmi-kcs"
RPROVIDES_${PN} = "virtual-obmc-host-ipmi-kcs"
#PREFERRED_PROVIDER_virtual/obmc-host-ipmi-hw = "phosphor-ipmi-kcs"

