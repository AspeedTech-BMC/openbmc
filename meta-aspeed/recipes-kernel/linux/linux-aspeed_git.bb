#KBRANCH ?= "dev-5.2"
#LINUX_VERSION ?= "5.2.9"

#SRCREV="e678af5dcf02b0d94d0bf9b3f90b349cbcb0097a"

#use aspeed github linux for now
KBRANCH ?= "aspeed-master-v5.1"
LINUX_VERSION ?= "5.1.3"

SRCREV="466b2520fa3bbedad4da77d3eaad33d3f8838b7f"

require linux-aspeed.inc
