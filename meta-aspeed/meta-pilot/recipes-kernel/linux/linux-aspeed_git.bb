KBRANCH ?= "aspeed-linux-4.19-pilot4-address-change"
LINUX_VERSION ?= "4.19.15"

SRCREV="ad9da99bbadaa78921249cf46616cd9e4ba0b724"
#SRCREV="${AUTOREV}"

require linux-aspeed.inc

